## Kconfig
```kconfig
mainmenu "FireworkOS"
config FIREWORK_HOST_SIM
 bool "Host simulator"
 default y
```
